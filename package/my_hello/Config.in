## package/my_hello/Config.in
```kconfig
config BR2_PACKAGE_MY_HELLO
	bool "my_hello"
	help
	  a test package
	  
	  http://www.test.com
	  
```
